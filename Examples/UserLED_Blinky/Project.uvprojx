# Keil uVision project Project.uvprojx, settings and files
target UserLED_Blinky (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: UserLED_Blinky +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c include: .\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./: stm32f10x_it.c main.c
  group FWLib
    ./FWLib/: STM32F10xR.LIB
  group RVMDK
    ./: stm32f10x_vector.s
software components: CMSIS:CORE 5.0.1
